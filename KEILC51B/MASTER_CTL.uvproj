# Keil uVision project MASTER_CTL.uvproj, settings and files
target MASTER_CTL (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: MASTER_CTL +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\START;.\Hardware\IO_FUNC;.\Hardware\USART;.\Hardware\TIM;.\Hardware\ADC
  group START
    ./START/: STC15F2K60S2.H
  group HARDWARE
    ./Hardware/USART/: USART.C
    ./Hardware/IO_FUNC/: IO_FUNC.C
    ./Hardware/TIM/: TIM.C
    ./Hardware/ADC/: ADC.C
  group USER
    ./USER/: main.c Interrupt.c
